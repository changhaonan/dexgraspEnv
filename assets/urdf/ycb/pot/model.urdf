Commit message: added hammer and torch

File: assets/urdf/ycb/pot/model.urdf (robot description, URDF)
Before this commit: robot Threshold_Porcelain_Pitcher_White, 1 links, 0 joints
Links:
- link Threshold_Porcelain_Pitcher_White__link_0: mass 0 -> 0.000017
